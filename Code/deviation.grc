options:
  parameters:
    author: Mario Vano
    generate_options: qt_gui
    id: deviation
    output_language: python
    title: FMDeviance 2.0
  states: {}

blocks:
- name: AF_DECIMATE
  id: variable
  parameters:
    value: '8'
  states: {}
- name: CALIBRATION
  id: variable
  parameters:
    value: '1'
  states: {}
- name: NBFM_TAU
  id: variable
  parameters:
    value: '750e-6'
  states: {}
- name: OutputSelect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,2
    label: '"                          Output"'
    label0: Radio
    label1: Tone
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
  states: {}
- name: REMOVE_DC
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,2
    label: '"Remove DC"'
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: RF_DECIMATE
  id: variable
  parameters:
    value: '4'
  states: {}
- name: RF_SCALE
  id: variable
  parameters:
    value: '32'
  states: {}
- name: TAU
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: Tone
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0
    label: '"Oscillator frequency  in Hz"'
    start: '10.0'
    step: '10'
    stop: '10000'
    value: '1000'
    widget: counter
  states: {}
- name: ToneLevel
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1
    label: '"     Relative Output  Level"'
    min_len: '100'
    start: '0'
    step: '.001'
    stop: '1'
    value: '0.01'
    widget: counter
  states: {}
- name: baseband
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1
    label: '"    Bandwidth in  Hz"'
    start: '100'
    step: '500'
    stop: '60000'
    value: '5000'
    widget: counter
  states: {}
- name: max_deviation
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    label: '"  deviation in KHz"'
    start: '0.5'
    step: '0.1'
    stop: '100'
    value: '5'
    widget: counter
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0
    label: '"rfgain"'
    start: '0'
    step: '.5'
    stop: '50'
    value: '40'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1
    label: '" squelch"'
    start: '0'
    step: '.1'
    stop: '10'
    value: '6'
    widget: slider
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: '"    FREQUENCY"'
    start: '30000000'
    step: '100'
    stop: '1300000000'
    value: '144390000'
    widget: counter
  states: {}
- name: tuning
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,0
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    value: 144.39e6
  states: {state: disabled}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2
    label: '" volume"'
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: whichTau
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,2
    label: '"                        Tau"'
    label0: NONE
    label1: 'NBFM: 750u'
    label2: WBFM:75u
    num_opts: '3'
    option0: '2'
    option1: '1'
    option2: '0'
    orient: Qt.QHBoxLayout
    type: int
    value: '2'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: NBFM_TAU
  states: {}
- name: analog_fm_deemph_1
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: TAU
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 0.63662 * CALIBRATION
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ToneLevel if (OutputSelect == 1) else 0
    comment: Test Oscillator
    freq: Tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale Display
    const: max_deviation
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume Control
    const: (volume * (OutputSelect==0)) / 10
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Squelch Gate
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_2
  id: blocks_rms_xx
  parameters:
    alpha: '0.005'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: not REMOVE_DC
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: whichTau
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-0.5'
    init: '0'
    low: '-1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: High Pass
    length: '512'
    long_form: 'False'
    type: ff
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: Squelch Filter
    cutoff_freq: max_deviation * 1000
    decim: '8'
    gain: squelch - (max_deviation/30)
    samp_rate: samp_rate * AF_DECIMATE
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Sets RF Bandwidth
    cutoff_freq: 2 *  (max_deviation * 1000) + baseband + 2000
    decim: RF_DECIMATE
    gain: '1'
    samp_rate: RF_SCALE * samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: baseband
    decim: AF_DECIMATE
    gain: 100.0/max_deviation
    samp_rate: samp_rate * AF_DECIMATE
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate *RF_SCALE
    comment: Debug probe
    fc: '0'
    fftsize: '1024'
    name: '"Debug probe"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    gui_hint: 1,0,1,3
    label1: p-p
    label2: RMS
    name: ''
    nconnections: '2'
    size: '768'
    srate: samp_rate
    tr_level: '0'
    type: float
    ylabel: peak deviation
    ymax: max_deviation
    ymin: '-max_deviation'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '30'
    freq0: tuning
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: RF_SCALE * samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_selector_1, '1']
- [analog_fm_deemph_1, '0', blocks_selector_1, '0']
- [analog_quadrature_demod_cf_0, '0', high_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_xx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_xx_0, '0', dc_blocker_xx_0, '0']
- [blocks_rms_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_rms_xx_2, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_selector_0, '0', analog_fm_deemph_0, '0']
- [blocks_selector_0, '0', analog_fm_deemph_1, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0, '0', blocks_selector_1, '2']
- [blocks_selector_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [high_pass_filter_0, '0', blocks_rms_xx_2, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
