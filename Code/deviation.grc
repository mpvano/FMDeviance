options:
  parameters:
    author: Mario Vano
    generate_options: qt_gui
    id: deviation
    output_language: python
    title: deviation
  states: {}

blocks:
- name: OutputSelect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,2
    label: '"Output"'
    label0: Radio
    label1: Tone
    num_opts: '2'
    option0: '1'
    option1: '0'
    type: real
    value: '1'
  states: {}
- name: REMOVE_DC
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,2
    label: HPF
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: Tone
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0
    label: Tone
    start: '10.0'
    step: '10'
    stop: '10000'
    value: '1000'
    widget: counter
  states: {}
- name: ToneLevel
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1
    label: Tone Level
    start: '0'
    step: '.001'
    stop: '1'
    value: '0.01'
    widget: counter
  states: {}
- name: calibration
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: max_deviation
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: max_deviation
    start: '0.5'
    step: '0.1'
    stop: '100'
    value: '5.0'
    widget: counter
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    label: '"                        rfgain"'
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1
    label: '"                    squelch"'
    start: '0'
    step: '10'
    stop: '500'
    value: '200'
    widget: dial
  states: {}
- name: tau_us
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1
    label: '"             Tau (us)"'
    start: '1'
    step: '1'
    stop: '150'
    value: '1'
    widget: counter
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: FREQUENCY
    start: '30000000'
    step: '100'
    stop: '500000000'
    value: '144390000'
    widget: counter
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2
    label: '"                      volume"'
    start: '0'
    step: '.05'
    stop: '1'
    value: '0.5'
    widget: dial
  states: {}
- name: RMS
  id: qtgui_number_sink
  parameters:
    avg: '0.7'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,1
    label1: '""'
    min: '0'
    name: '" "'
    type: float
    unit1: '"   RMS"'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: max_deviation * 1000
    quad_rate: 8* samp_rate
    tau: tau_us * 1e-6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ToneLevel if (OutputSelect == 0) else 0
    freq: Tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Calibration point
    const: calibration
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: (volume * .1) * OutputSelect
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1 * max_deviation'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0005'
    type: float
  states: {}
- name: blocks_rms_xx_2
  id: blocks_rms_xx
  parameters:
    alpha: '0.0005'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: not(REMOVE_DC)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-0.5'
    init: '0'
    low: '-1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '512'
    long_form: 'False'
    type: ff
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: squelch
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '4'
    gain: '1'
    samp_rate: 32*samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    color2: dark green
    gui_hint: 1,0,1,3
    label1: p-p
    label2: RMS
    name: FM Deviation
    nconnections: '2'
    size: '768'
    srate: samp_rate
    tr_level: '0'
    type: float
    ylabel: Max_deviation
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '30'
    freq0: tuning
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: 32* samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_xx_0, '0']
- [analog_nbfm_rx_0, '0', high_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_const_vxx_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_rms_xx_0, '0', RMS, '0']
- [blocks_rms_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_rms_xx_2, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_selector_0, '0', blocks_rms_xx_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [high_pass_filter_0, '0', blocks_rms_xx_2, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
