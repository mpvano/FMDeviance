options:
  parameters:
    author: Mario Vano
    generate_options: qt_gui
    id: deviation
    output_language: python
    title: FMDeviance 2.1
  states: {}

blocks:
- name: AF_DECIMATE
  id: variable
  parameters:
    value: '4'
  states: {}
- name: CALIBRATION
  id: variable
  parameters:
    value: '1'
  states: {}
- name: NBFM_TAU
  id: variable
  parameters:
    value: '750e-6'
  states: {}
- name: OutputSelect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,2
    label: '"Output"'
    label0: Radio
    label1: Oscillator
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
  states: {}
- name: REMOVE_DC
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,2
    label: '"Remove DC"'
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: RF_DECIMATE
  id: variable
  parameters:
    value: '6'
  states: {}
- name: TAU
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: Tone
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1
    label: '"Oscillator frequency  in Hz"'
    start: '10.0'
    step: '10'
    stop: '10000'
    value: '1000'
    widget: counter
  states: {}
- name: ToneLevel
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0
    label: '"   Oscillator Output  Level"'
    min_len: '100'
    start: '0'
    step: '.001'
    stop: '1'
    value: '0.01'
    widget: counter
  states: {}
- name: baseband
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    label: '"AF Bandwidth in  Hz"'
    start: '100'
    step: '500'
    stop: samp_rate / 2 - 2000
    value: '5000'
    widget: counter
  states: {}
- name: max_deviation
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1
    label: '"  Deviation in KHz"'
    start: '0.5'
    step: '0.1'
    stop: '100'
    value: '5'
    widget: counter
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0
    label: '"RF Gain"'
    start: '0'
    step: '.5'
    stop: '50'
    value: '25'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 96000 if sampleRate ==96000 else 48000
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1
    label: '" Squelch"'
    start: '0'
    step: '.1'
    stop: '15'
    value: '7'
    widget: slider
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: '"    FREQUENCY"'
    start: '30000000'
    step: '100'
    stop: '1300000000'
    value: '144390000'
    widget: counter
  states: {}
- name: tuning
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,1
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    value: 144.39e6
  states: {state: disabled}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2
    label: '" Volume"'
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: whichTau
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,2
    label: '"    Tau"'
    label0: None
    label1: 'WBFM: 75u'
    label2: NBFM:750u
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: NBFM_TAU
  states: {}
- name: analog_fm_deemph_1
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: TAU
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 0.63662 * CALIBRATION
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ToneLevel if (OutputSelect == 1) else 0
    comment: Test Oscillator
    freq: Tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale Display
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume Control
    const: (volume * .01 * (OutputSelect==0))
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Squelch Gate
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_2
  id: blocks_rms_xx
  parameters:
    alpha: '0.005'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: not REMOVE_DC
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: whichTau
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-0.5'
    init: '0'
    low: '-1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: High Pass
    length: '512'
    long_form: 'False'
    type: ff
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: |-
      Squelch Filter
      argument specifications are
      WRONG for real  mode filter
      and must be scaled
    cutoff_freq: baseband/3.8
    decim: AF_DECIMATE
    gain: squelch/ (max_deviation/8)
    samp_rate: samp_rate
    type: fir_filter_fff
    width: baseband / 20
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Sets RF Bandwidth
    cutoff_freq: ' (2 * (max_deviation * 1000) + baseband)'
    decim: RF_DECIMATE
    gain: '1'
    samp_rate: samp_rate * RF_DECIMATE * AF_DECIMATE
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      argument specifications are
      WRONG for real  mode filter
      and must be scaled
    cutoff_freq: baseband/3.8
    decim: AF_DECIMATE
    gain: samp_rate / 1000
    samp_rate: samp_rate
    type: fir_filter_fff
    width: baseband /20
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,1
    label: 96K
    maxSize: '20'
    offColor: white
    state: sampleRate ==  96000
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate * 10
    comment: Debug probe
    fc: '0'
    fftsize: '8192'
    name: '"Debug probe"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    gui_hint: 1,0,1,3
    label1: p-p
    label2: RMS
    name: ''
    nconnections: '2'
    size: '768'
    srate: samp_rate
    tr_level: '0'
    type: float
    ylabel: peak deviation
    ymax: max_deviation
    ymin: '-max_deviation'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '30'
    freq0: tuning
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate * RF_DECIMATE * AF_DECIMATE
    sync: sync
    type: fc32
  states: {}
- name: sampleRate
  id: parameter
  parameters:
    comment: 'default: 48000  or 96000'
    short_id: s
    type: intx
    value: '48000'
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_selector_1, '2']
- [analog_fm_deemph_1, '0', blocks_selector_1, '1']
- [analog_quadrature_demod_cf_0, '0', high_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_xx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_xx_0, '0', dc_blocker_xx_0, '0']
- [blocks_rms_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_rms_xx_2, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_selector_0, '0', analog_fm_deemph_0, '0']
- [blocks_selector_0, '0', analog_fm_deemph_1, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0, '0', blocks_selector_1, '0']
- [blocks_selector_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [high_pass_filter_0, '0', blocks_rms_xx_2, '0']
- [high_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
